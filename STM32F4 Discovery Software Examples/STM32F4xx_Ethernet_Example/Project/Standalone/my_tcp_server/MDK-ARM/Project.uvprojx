# Keil uVision project Project.uvprojx, settings and files
target Discover-More (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F4-Discovery;..\..\..\..\Utilities\lwip_v1.3.2\port\STM32F4x7;..\..\..\..\Utilities\lwip_v1.3.2\port\STM32F4x7\Standalone;..\..\..\..\Utilities\lwip_v1.3.2\src\include;..\..\..\..\Utilities\lwip_v1.3.2\src\include\ipv4;..\..\..\..\Utilities\lwip_v1.3.2\src\include\lwip;..\..\..\..\Utilities\lwip_v1.3.2\src\include\netif;..\inc;..\src;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c system_stm32f4xx.c stm32f4xx_it.c netconf.c stm32f4x7_eth_bsp.c tcp_echoserver.c serial_debug.c data_sample.c
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery_lcd.c stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_spi.c
  group STM32F4x7_ETH_Driver
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group LWIP
    ../../../../Utilities/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
    ../../../../Utilities/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../Utilities/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../../Utilities/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../Utilities/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group readme
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
